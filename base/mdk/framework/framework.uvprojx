# Keil uVision project framework.uvprojx, settings and files
target nano_framework (6190000::V6.19::ARMCLANG)
  device: MM32F5277E7PV MindMotion
  pack: MindMotion.MM32F5277E_DFP.1.3.0
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: nano_demo +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,CUSTOM_HSE_VAL
  c include: ..\..\UART_Interrupt;..\..\library\CMSIS\Core\Include;..\..\library\MM32F5270\HAL_Lib\Inc;..\..\library\MM32F5270\Include;..\..\rtthread-nano-4.1.1\rt-thread\bsp\_template;..\..\rtthread-nano-4.1.1\rt-thread\include;..\..\rtthread-nano-4.1.1\rt-thread\libcpu\arm\cortex-m33;..\..\rtthread-nano-4.1.1\rt-thread\components\finsh;..\..\plat;..\..\core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: ..\..\library\MM32F5270\Source\mm32f5270.sct
  group core
    ../../core/: main.c mm32f5270_it.c
  group plat
    ../../plat/: platform.c mm32_uart.c mm32_adc.c mm32_gpio.c
  group doc
    ./: readme.md
  group HAL_LIB
    ../../library/MM32F5270/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_cordic.c hal_crcpoly.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_enet.c hal_exti.c hal_flash.c hal_flexcan.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_mds.c hal_misc.c hal_pwr.c hal_qspi.c hal_rcc.c hal_rtc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_usbfs.c hal_wwdg.c
  group STARTUP
    ../../library/MM32F5270/Source/: system_mm32f5270.c
    ../../library/MM32F5270/Source/KEIL_StartAsm/: startup_mm32f5270_keil.c
  group rtthread/src
    ../../rtthread-nano-4.1.1/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rtthread/port
    ../../rtthread-nano-4.1.1/rt-thread/libcpu/arm/cortex-m33/: cpuport.c context_gcc.S trustzone.c
  group rtthread/board
    ../../rtthread-nano-4.1.1/rt-thread/bsp/_template/: board.c
  group rtthread/finsh
    ../../rtthread-nano-4.1.1/rt-thread/components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
